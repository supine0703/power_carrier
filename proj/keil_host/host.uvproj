# Keil uVision project host.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: host +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
  group main
    ./: STARTUP.A51 __config__.h main.c
  group include
    ../include/: lcd1602.h
  group src
    ../src/: lcd1602.c global.c
