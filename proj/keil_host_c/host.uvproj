# Keil uVision project host.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: host_c +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
  group main
    ./: STARTUP.A51 main.c __config__.h
  group include
    ../include/: crc16.h instructions.h lcd1602.h serialport_2.h
  group src
    ../src/: crc16.c global.c lcd1602.c serialport_2.c
