# Keil uVision project slave.uvproj, settings and files
target 0 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
  group main
    ./: STARTUP.A51 __config__.h main.c
  group include
    ../include/: lcd1602.h serialport.h instructions.h
  group src
    ../src/: lcd1602.c serialport.c global.c
target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: slave1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
target 2 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: slave2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
target 3 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: slave3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
target 4 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: slave4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
