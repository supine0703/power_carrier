# Keil uVision project host.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: host_a +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\src
  group main
    ./: STARTUP.A51 __config__.h main.c
  group include
    ../include/: lcd1602.h serialport.h utility.h instructions.h crc16.h
  group src
    ../src/: lcd1602.c serialport.c utility.c global.c crc16.c
